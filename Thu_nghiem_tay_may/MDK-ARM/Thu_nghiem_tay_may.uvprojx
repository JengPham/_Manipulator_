# Keil uVision project Thu_nghiem_tay_may.uvprojx, settings and files
target Thu_nghiem_tay_may (6190000::V6.19::ARMCLANG)
  device: STM32F746ZETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Thu_nghiem_tay_may +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: Invert_Kinematic.c Step_motor.c Analog.c MCP4822.c UART.c main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
    ../Core/Inc/: Invert_Kinematic.h Step_motor.h Analog.h MCP4822.h UART.h
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
software components: CMSIS:CORE 5.6.0
